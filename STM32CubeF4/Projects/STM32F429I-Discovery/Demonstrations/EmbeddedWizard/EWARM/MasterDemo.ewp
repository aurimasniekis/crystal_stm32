# IAR project MasterDemo.ewp, settings and files
configuration STM32F429I-Discovery (ARM, debug)
  General.OGChipSelectEditMenu: STM32F429ZI ST STM32F429ZI
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32F429xx; USE_STM32F429I_DISCO; HSE_VALUE=8000000; EW_MAX_SURFACE_CACHE_SIZE=0x100000; EW_MAX_GLYPH_SURFACE_WIDTH=256; EW_MAX_GLYPH_SURFACE_HEIGHT=256; EW_USE_OFFSCREEN_BUFFER=0; EW_USE_DOUBLE_BUFFER=1; EW_FRAME_BUFFER_COLOR_FORMAT=EW_FRAME_BUFFER_COLOR_FORMAT_RGB565; EW_SURFACE_ROTATION=0; EW_USE_QSPI_FLASH=0; EW_CPU_LOAD_MEASURING=1; EW_USE_FREE_RTOS=0
  ICCARM.CCIncludePath2: ..\Core\Inc; ..\EmbeddedWizard\TargetSpecific; ..\EmbeddedWizard\GeneratedCode; ..\..\..\..\..\Middlewares\ST\EmbeddedWizard\PlatformPackage\RGB565\inc; ..\..\..\..\..\Middlewares\ST\EmbeddedWizard\PlatformPackage\RTE\inc; ..\..\..\..\..\Middlewares\ST\EmbeddedWizard\Misc\inc; ..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32F4xx\Include; ..\..\..\..\..\Drivers\STM32F4xx_HAL_Driver\Inc; ..\..\..\..\..\Drivers\BSP\STM32F429I-Discovery
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: STM32F429I_DISCOVERY.hex
  ILINK.IlinkOutputFile: Project.out
  ILINK.IlinkIcfFile: stm32f429xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_stm32f429xx.s
  group Application/User/Core
    ../Core/Src/: main.c stm32f4xx_it.c
  group Application/User/EmbeddedWizard/GeneratedCode
    ../EmbeddedWizard/GeneratedCode/: Accelerator.c AnimatedList.c Application.c Charts.c Climate.c Core.c Effects.c Flat.c Graphics.c MasterDemo.c Resources.c Views.c Waveform.c
  group Application/User/EmbeddedWizard/TargetSpecific
    ../EmbeddedWizard/TargetSpecific/: ew_bsp_clock.c ew_bsp_display.c ew_bsp_event.c ew_bsp_graphics.c ew_bsp_inout.c ew_bsp_serial.c ew_bsp_system.c ew_bsp_touch.c
  group Doc
    ../: readme.txt
  group Drivers/BSP/Components
    ../../../../../Drivers/BSP/Components/ili9341/: ili9341.c
    ../../../../../Drivers/BSP/Components/stmpe811/: stmpe811.c
  group Drivers/BSP/STM32F429I_DISCO
    ../../../../../Drivers/BSP/STM32F429I-Discovery/: stm32f429i_discovery.c stm32f429i_discovery_io.c stm32f429i_discovery_lcd.c stm32f429i_discovery_sdram.c stm32f429i_discovery_ts.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
  group Drivers/STM32F4xx_HAL_Driver
    ../../../../../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_cortex.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma2d.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_gpio.c stm32f4xx_hal_hcd.c stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_i2s.c stm32f4xx_hal_ltdc.c stm32f4xx_hal_pcd.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_rtc.c stm32f4xx_hal_rtc_ex.c stm32f4xx_hal_sdram.c stm32f4xx_hal_spi.c stm32f4xx_hal_uart.c stm32f4xx_ll_fmc.c
  group Middlewares/EmbeddedWizard/Misc
    ../../../../../Middlewares/ST/EmbeddedWizard/Misc/src/: tlsf.c xprintf.c
  group Middlewares/EmbeddedWizard/PlatformPackage/RGB565
    ../../../../../Middlewares/ST/EmbeddedWizard/PlatformPackage/RGB565/src/: ewextgfx.c
    ../../../../../Middlewares/ST/EmbeddedWizard/PlatformPackage/RGB565/lib/: libewgfx-m4-r90-iar.a
  group Middlewares/EmbeddedWizard/PlatformPackage/RTE
    ../../../../../Middlewares/ST/EmbeddedWizard/PlatformPackage/RTE/src/: ewextrte.c
    ../../../../../Middlewares/ST/EmbeddedWizard/PlatformPackage/RTE/lib/: libewrte-m4-iar.a
